FILESEXTRAPATHS:prepend :="${THISDIR}/files/:"

SRC_URI += "file://0001-Readme.md-modified-some-tect.patch"
